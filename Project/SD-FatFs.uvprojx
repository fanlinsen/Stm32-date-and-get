# Keil uVision project SD-FatFs.uvprojx, settings and files
target IK-ZET6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SD-FatFs +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Lib\F10x_FWLIB\inc;..\User;..\User\FATFS;..\User\led;..\User\usart;..\User\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../User/: main.c stm32f10x_it.c led.c user_exti.c huange.c user_systick.c user_rtc.c
    ../User/led/: bsp_led.c
    ../User/sdio/: bsp_sdio_sdcard.c
    ../User/usart/: bsp_usart.c
    ../User/can/: user_can.c
  group F10x_FWLIB
    ../Lib/F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DOC
    ../Doc/: 实验说明.txt
  group FatFs
    ../User/FATFS/: diskio.c ff.c
    ../User/FATFS/option/: cc936.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
